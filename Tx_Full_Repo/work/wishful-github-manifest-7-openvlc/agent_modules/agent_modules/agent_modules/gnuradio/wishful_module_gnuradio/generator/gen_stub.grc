<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>session_var</value></param>
<param><key>value</key><value>[0, 1, 2, 3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_addr</value></param>
<param><key>value</key><value>"addr=192.168.20.2"</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>protocol_selector_template</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>3</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>output_index</key><value>session_var[0]</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_template</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>dev_addr</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>session_var[1]</value></param>
<param><key>center_freq0</key><value>session_var[2]</value></param>
<param><key>gain0</key><value>session_var[3]</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_template</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>8080</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_template</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_template</source_block_id><sink_block_id>protocol_selector_template</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
