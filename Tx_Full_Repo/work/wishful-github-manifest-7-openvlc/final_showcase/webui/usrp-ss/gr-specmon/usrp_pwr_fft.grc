<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_pwr_fft</value></param>
<param><key>author</key><value>Mikołaj Chwalisz</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>USRP Spectrum Monitor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_rate</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>label</key><value>Collected bandwidth</value></param>
<param><key>short_id</key><value>b</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>22000000</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>blocksize</key><value>fft_size/2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>measurement.cfile</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>fft_size/2, fft_size/2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>minoutbuf</key><value>2024</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_frequency</value></param>
<param><key>label</key><value>Center frequency</value></param>
<param><key>short_id</key><value>c</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2462000000</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>dropper</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Dropper',   # will show up in GRC
            in_sig=[np.complex64],
            out_sig=[np.complex64]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.message_port_register_in(pmt.intern('drop'))
        self.set_msg_handler(pmt.intern('drop'), self.handle_msg)
        self.drop = False

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        # if not self.drop:
        output_items[0][:] = input_items[0]
        return len(input_items[0])

    def handle_msg(self, msg):
        self.drop = pmt.to_bool(msg)
</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>1.0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>frame_rate</key><value>1000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>bandwidth</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>bandwidth</value></param>
<param><key>center_freq0</key><value>center_frequency</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>usrp_addr</value></param>
<param><key>minoutbuf</key><value>2024</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>bandwidth</value></param>
<param><key>hide_cmd_port</key><value>True</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>otw</key><value>sc16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>usrp_addr</value></param>
<param><key>label</key><value>Select USRP</value></param>
<param><key>short_id</key><value>u</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"type=b200"</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>waterfall_file_sink</value></param>
<param><key>_source_code</key><value>"""
Plotting Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt
from multiprocessing import Process
# from threading import Thread
import matplotlib as mpl
mpl.use("Agg")
import matplotlib.pyplot as plt
from datetime import datetime
# import zmq

cmap = plt.get_cmap("viridis")


def gen_spectrogram(data, rx_freq=None, rx_rate=None):
    ax = plt.gca()
    time_size, freq_size = data.shape
    ax.imshow(
        data.T,
        cmap=cmap,
        aspect='auto',
        interpolation='nearest',
        # extent=(
        #     data.index[0],
        #     data.index[-1],
        #     data.columns[0],
        #     data.columns[-1]
        # ),
        origin='lower',
    )

    def y_freq(y, pos):
        result = (y + 1) * rx_rate/ freq_size - rx_rate / 2 + rx_freq
        result = result / 1e6
        return '{:,.0f}'.format(result)

    if rx_rate and rx_freq:
        ax.yaxis.set_major_formatter(mpl.ticker.FuncFormatter(y_freq))
        ax.yaxis.set_minor_formatter(mpl.ticker.FuncFormatter(y_freq))
        ax.set_ylabel('Frequency (MHz)')
    fig = plt.gcf()
    fname = 'data/usrp_' + str(datetime.now())
    fig.savefig('test.png')
    fig.savefig(fname + '.png')
    np.savetxt(fname + '.csv', data, delimiter=',')

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Waterfall Plot to File Sink

    It will plot Waterfall plot of `freq_size` and `num_Samples`.
    """

    def __init__(self, freq_Size=256, num_Samples=1000):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        self.freq_size = freq_Size
        gr.sync_block.__init__(
            self,
            name='Waterfall Plot to File Sink',   # will show up in GRC
            in_sig=[(np.float32, 256)],
            out_sig=None,
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.nsamples = num_Samples
        self.worker = Process()
        self.message_port_register_out(pmt.intern('drop'))
        self.drop = False
        self.rx_freq = None
        self.rx_rate = None

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        if self.worker.is_alive():
            return len(input_items[0])

        if self.drop:
            self.drop = False
            self.message_port_pub(
                pmt.intern('drop'),
                pmt.from_bool(False),
            )


        if input_items[0].shape[0] == self.nsamples:
            print(datetime.now())

            tags = self.get_tags_in_window(0,0, self.nsamples)
            for tag in tags:
                tag = gr.tag_to_python(tag)
                if tag.key == 'rx_freq':
                    self.rx_freq = tag.value
                if tag.key == 'rx_rate':
                    self.rx_rate = tag.value

            self.worker = Process(
                target=gen_spectrogram,
                args=(
                    input_items[0].copy(),
                    self.rx_freq,
                    self.rx_rate,
                ))
            # self.worker.setDaemon(True)
            self.worker.start()

            self.message_port_pub(
                pmt.intern('drop'),
                pmt.from_bool(True))

            self.drop = True
            return self.nsamples

        return 0

</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_Size</key><value>fft_size</value></param>
<param><key>num_Samples</key><value>1000</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>waterfall_zmq_sink</value></param>
<param><key>addr</key><value>zmq_addr</value></param>
<param><key>_source_code</key><value>"""
Plotting Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import datetime
import zmq
import json


class blk(gr.sync_block):
    """Waterfall ZMQ Sink

    It will send Waterfall plot data over ZMQ PUB socket.
    """

    def __init__(self,
            freq_Size=128,
            num_Samples=1000,
            msg_interval=1000,
            addr='tcp://localhost:5507'):
        """arguments to this function show up as parameters in GRC"""
        self.freq_size = freq_Size
        gr.sync_block.__init__(
            self,
            name='Waterfall ZMQ Sink',   # will show up in GRC
            in_sig=[(np.float32, freq_Size)],
            out_sig=None,
        )
        self.nsamples = num_Samples
        self.msg_interval = datetime.timedelta(milliseconds=msg_interval)
        self.rx_freq = None
        self.rx_rate = None
        self.done = False

        context = zmq.Context()
        self.sock = context.socket(zmq.PUB)
        self.sock_addr = addr
        self.sock_connected = False
        self.last_msg_time = datetime.datetime.now()

    def work(self, input_items, output_items):
        if not self.sock_connected:
            print('Connecting to {}'.format(self.sock_addr))
            self.sock.connect(self.sock_addr)
            self.sock_connected = True
        current_time = datetime.datetime.now()

        if ((current_time - self.last_msg_time)
                &gt; datetime.timedelta(seconds=10)):
            return -1

        tags = self.get_tags_in_window(0, 0, self.nsamples)
        for tag in tags:
            tag = gr.tag_to_python(tag)
            if tag.key == 'rx_freq':
                self.rx_freq = tag.value
            if tag.key == 'rx_rate':
                self.rx_rate = tag.value
        # if (self.last_msg_time + self.msg_interval) &gt; current_time:
        if self.done:
            self.done = False
            return len(input_items[0])
        if input_items[0].shape[0] == self.nsamples:
            self.send_message(input_items[0])
            self.last_msg_time = datetime.datetime.now()
            self.done = True
            return self.nsamples
        return 0

    def send_message(self, data):
        now = datetime.datetime.now()
        data = data.T
        l, w = data.shape
        info = {'l': l, 'w': w, 'fc': self.rx_freq, 'bw': self.rx_rate}
        full_msg = [
            b'gnuradio.spectrogram',
            json.dumps(info).encode('utf-8'),
            data.ravel().tobytes(),
        ]
        self.sock.send_multipart(full_msg)
        print('i: %s, p: %s %s' % (
            str(now - self.last_msg_time),
            str(datetime.datetime.now() - now),
            str(self.sock_connected),
        ))
</value></param>
<param><key>freq_Size</key><value>fft_size</value></param>
<param><key>msg_interval</key><value>1000</value></param>
<param><key>num_Samples</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zmq_addr</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"tcp://localhost:5507"</value></param>
</block>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>waterfall_file_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>waterfall_zmq_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dropper</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>dropper</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>waterfall_file_sink</source_block_id><sink_block_id>dropper</sink_block_id><source_key>drop</source_key><sink_key>drop</sink_key></connection>
</flow_graph>
